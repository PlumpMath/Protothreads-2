# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\soure;.\soure\pt1_4
  group Source Group 1
    ./soure/: main.c Uart.c
